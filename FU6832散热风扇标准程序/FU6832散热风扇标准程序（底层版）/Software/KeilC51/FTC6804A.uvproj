# Keil uVision project FTC6804A.uvproj, settings and files
target FTC6804A (MCS-51)
  device: FU6832 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: AVC_ProjectV1_0_7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FU68xx_Hardware_Driver\Include;..\User\include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/Application/: AddFunction.c turboFanFunction.c HPFCOL_Function.c Interrupt.c main.c HPFCOL_Data.c
    ../User/include/: Customer.h Parameter.h Protect.h Develop.h
  group Function
    ../User/source/Function/: MotorControl.c MotorControlFunction.c ACLostFunc.c MotorTailWind.c MotorProtect.c PWM_SpeedControl.c SignalOutputControl.c
  group HardWare
    ../User/source/Hardware/: ADC.c AMP.c CMP.c CRC.c DMA.c DRIVER.c FLASH.c GPIO.c I2C.c SPI.c TIMER.c UART.c PID.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: STARTUP_FU6804.A51
  group Document
    ../Document/: DebugLog.txt Versionlog.txt
